# IAR project Project.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R9AI ST STM32L4R9AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4R9xx; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\core\inc; ..\platform\inc; ..\..\..\sdk\Drivers\CMSIS\Include; ..\..\..\sdk\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\sdk\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\sdk\Drivers\BSP\STM32L4R9I-Discovery; ..\..\..\sdk\Drivers\BSP\Components\Common; ..\..\..\thirdparty\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\thirdparty\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\thirdparty\FreeRTOS\Source\include; ..\ui\inc; ..\qb\inc; ..\trace\inc; ..\thirdparty\systemview\inc; ..\thirdparty\systemview-freertos\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\core\inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l4r9xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: stm32l4r9xx_flash.icf
  group microej/core
    ../core/src/: cpuload.c cpuload_impl_FreeRTOS.c fault_handlers.c hooks_FreeRTOS.c interrupts.c LLBSP_stm32.c LLDEVICE_impl.c LLMJVM_FreeRTOS.c LLSP_FreeRTOS.c main.c microej_time.c microjvm_main.c platform_init.c putchar.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c system_stm32l4xx.c
    ./: startup_stm32l4r9xx.s
  group microej/platform
    ../platform/lib/: microejapp.o microejruntime.a
  group microej/trace
    ../trace/src/: LLMJVM_MONITOR_sysview.c LLTRACE_sysview.c
    ../thirdparty/systemview/src/: SEGGER_RTT.c SEGGER_SYSVIEW.c
    ../thirdparty/systemview-freertos/src/: SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c
  group microej/ui
    ../ui/src/: buttons_helper.c event_generator.c framerate.c joystick_manager.c lcd_driver.c LLDW_PAINTER_impl.c LLUI_DISPLAY_HEAP_impl.c LLUI_DISPLAY_impl.c LLUI_INPUT_impl.c LLUI_INPUT_LOG_impl.c LLUI_PAINTER_impl.c mfx_v3.c microui_event_decoder.c microui_rotation.c touch_helper.c touch_manager.c
  group sdk/Drivers
    ../../../sdk/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_fmc.c
  group sdk/Drivers/BSP/Components
    ../../../sdk/Drivers/BSP/Components/ft3x67/: ft3x67.c
    ../../../sdk/Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group sdk/Drivers/BSP/STM32L4R9I-Discovery
    ../../../sdk/Drivers/BSP/STM32L4R9I-Discovery/: stm32l4r9i_discovery.c stm32l4r9i_discovery_io.c stm32l4r9i_discovery_ospi_nor.c stm32l4r9i_discovery_psram.c stm32l4r9i_discovery_ts.c
  group sdk/Drivers/STM32L4xx_HAL_Driver
    ../../../sdk/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dsi.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_usart.c
  group thirdparty/FreeRTOS
    ../../../thirdparty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group thirdparty/FreeRTOS/CMSIS_RTOS
    ../../../thirdparty/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group thirdparty/FreeRTOS/portable
    ../../../thirdparty/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../thirdparty/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
